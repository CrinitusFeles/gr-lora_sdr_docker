options:
  parameters:
    author: xor
    generate_options: no_gui
    id: RX_TX
    output_language: python
    title: RX_TX
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '437000000'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '1'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: input_index
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ldro
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: output_index
  id: variable
  parameters:
    value: '0'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sf
  id: variable
  parameters:
    value: '10'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '18'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: center_freq
  states: {}
- name: blocks_msgpair_to_var_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: bw
  states: {}
- name: blocks_msgpair_to_var_0_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: has_crc
  states: {}
- name: blocks_msgpair_to_var_0_1
  id: blocks_msgpair_to_var
  parameters:
    target: sf
  states: {}
- name: blocks_msgpair_to_var_0_1_0
  id: blocks_msgpair_to_var
  parameters:
    target: input_index
  states: {}
- name: blocks_msgpair_to_var_0_1_0_0
  id: blocks_msgpair_to_var
  parameters:
    target: output_index
  states: {}
- name: blocks_msgpair_to_var_1
  id: blocks_msgpair_to_var
  parameters:
    target: cr
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: input_index
    num_inputs: '2'
    num_outputs: '2'
    output_index: output_index
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: input_index
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: input_index
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    minoutbuf: '65536'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, out0_key='', out1_key='', out2_key='', out3_key='', out4_key='', out5_key='', out6_key=''):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='MSG_HANDLER',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              self.keys = [out0_key, out1_key, out2_key, out3_key, out4_key, out5_key, out6_key]
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              for i in range(7):
                  self.message_port_register_out(pmt.intern(f'out{i}'))
                  print(f'registered variable: {self.keys[i]}')

          def handle_msg(self, msg):
              value = pmt.to_python(msg)
              if isinstance(value, dict):
                  print(f'Got config msg: {value}')
                  for key, val in value.items():
                      if key in self.keys:
                          print(f'got msg for port{self.keys.index(key)}.')
                          self.message_port_pub(pmt.intern(f'out{self.keys.index(key)}'), pmt.cons(pmt.intern(key), pmt.to_pmt(val)))
              else:
                  print('msg is not dict!')


          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] # * self.example_param
              return len(output_items[0])
    out0_key: '''output_index'''
    out1_key: '''input_index'''
    out2_key: '''sf'''
    out3_key: '''center_freq'''
    out4_key: '''cr'''
    out5_key: '''bw'''
    out6_key: '''has_crc'''
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '1'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: int(center_freq)
    impl_head: 'False'
    os_factor: int(samp_rate/bw)
    preamb_len: '8'
    sf: sf
    show_log_port: 'False'
    sync_word: sync_word
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: 'False'
    ldro: ldro
    pay_len: pay_len
    print_header: 'True'
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: '125000'
    cr: cr
    ldro: ldro
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    frame_zero_padd: int(20*2**sf*int(samp_rate/bw))
    preamb_len: '8'
    samp_rate: samp_rate
    sf: sf
    sync_words: sync_word
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'True'
    length_tag_name: '''pay_len'''
    separator: ''','''
    source_type: message_strobe
    use_length_tag: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '437000000'
    fftsize: '1024'
    rate: '60'
    type: complex
    wintype: window.WIN_HAMMING
  states: {state: disabled}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: center_freq
    dev_args: 0000000000000000081c69dc2f5e9e1b
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: center_freq
    dev_args: 0000000000000000081c69dc2f5e9e1b
    gain: '24'
    samp_rate: samp_rate
    type: fc32
    vga: '24'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: frame_info
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: hack_rf_source
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: frame_info
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: hack_rf_source
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://192.168.0.105:5502
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://192.168.0.105:5500
    timeout: '100'
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://0.0.0.0:5501
    pass_tags: 'True'
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_selector_0_0, '1']
- [blocks_null_source_0_0, '0', blocks_selector_0_0_0, '0']
- [blocks_selector_0, '0', blocks_throttle_0, '0']
- [blocks_selector_0, '1', blocks_selector_0_0_0, '1']
- [blocks_selector_0, '1', soapy_hackrf_sink_0, '0']
- [blocks_selector_0_0, '0', blocks_selector_0, '0']
- [blocks_selector_0_0_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', virtual_sink_1, '0']
- [epy_block_0, out0, blocks_msgpair_to_var_0_1_0_0, inpair]
- [epy_block_0, out1, blocks_msgpair_to_var_0_1_0, inpair]
- [epy_block_0, out2, blocks_msgpair_to_var_0_1, inpair]
- [epy_block_0, out3, blocks_msgpair_to_var_0, inpair]
- [epy_block_0, out4, blocks_msgpair_to_var_1, inpair]
- [epy_block_0, out5, blocks_msgpair_to_var_0_0, inpair]
- [epy_block_0, out6, blocks_msgpair_to_var_0_0_0, inpair]
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_crc_verif_0, '0', blocks_tag_debug_0, '0']
- [lora_sdr_crc_verif_0, '0', zeromq_push_sink_0, '0']
- [lora_sdr_crc_verif_0, msg, blocks_message_debug_0, print]
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, virtual_sink_0, '0']
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', blocks_selector_0, '1']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [soapy_hackrf_source_0, '0', blocks_selector_0_0, '0']
- [virtual_source_0, '0', lora_sdr_frame_sync_0, frame_info]
- [virtual_source_0_0, '0', lora_sdr_frame_sync_0, '0']
- [zeromq_pull_msg_source_0, out, blocks_message_debug_0_0, print]
- [zeromq_pull_msg_source_0, out, epy_block_0, msg_in]
- [zeromq_pull_msg_source_0_0, out, blocks_message_debug_0_0, print]
- [zeromq_pull_msg_source_0_0, out, lora_sdr_whitening_0, msg]

metadata:
  file_format: 1
  grc_version: 3.10.3.0
